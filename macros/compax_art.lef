VERSION 5.8 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS
MACRO compax_art
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  FOREIGN compax_art 0 0 ;
  SIZE 60 BY 66 ;
  SYMMETRY X Y ;
  OBS
    LAYER met4 ;
    RECT 0 0 60 66 ;
  END
END compax_art
END LIBRARY
